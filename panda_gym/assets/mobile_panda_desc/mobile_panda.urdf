Commit message: add mobile reach, adjust for hgg

File: panda_gym/assets/mobile_panda_desc/mobile_panda.urdf (robot description, URDF)
Before this commit: robot mobile_panda, 24 links, 23 joints
Joints:
- joint panda_joint0: parent top_plate_link -> user_rail_link
